# Keil uVision project 07_Encoder.uvprojx, settings and files
target 07_Encoder (6220000::V6.22::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 07_Encoder +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\User\Module\0.91 OLED;../User/Module/Ebtn;../User/Module/Grayscale;../User/Module/Ringbuffer;../User/Driver;../User/App;../User;..\User\Module\PID;..\..\lvgl;..\..\lvgl\src;E:\校电赛
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group User/Module/Ebtn
    ../User/Module/Ebtn/: ebtn.c
  group User/Module/Ringbuffer
    ../User/Module/Ringbuffer/: ringbuffer.c
  group User/Module/0.91 OLED
    ../User/Module/0.91 OLED/: oled.c
  group User/Module/Grayscale
    ../User/Module/Grayscale/: hardware_iic.c
  group User/Driver
    ../User/Driver/: led_driver.c key_driver.c uart_driver.c oled_driver.c motor_driver.c encoder_driver.c
  group User/App
    ../User/App/: led_app.c key_app.c uart_app.c oled_app.c gray_app.c motor_app.c encoder_app.c ui_animation_app.c ui_animation_app.h ui_menu_app.c ui_menu_app.h ui_page_app.c ui_page_app.h pid_app.c pid_app.h lv_port_disp.c lvgl_app.c
  group User
    ../User/: MyDefine.h Scheduler.c Scheduler_Task.c
    ../User/Module/PID/: pid.c
  group LVGL
    ../../lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../lvgl/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_montserrat_12.c lv_font_montserrat_14.c
    ../../lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL/Draw
    ../../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group LVGL/Extra
    ../../lvgl/src/extra/: lv_extra.c
    ../../lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../lvgl/src/extra/layouts/grid/: lv_grid.c
  group LVGL/Widgets_Extra
    ../../lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../lvgl/src/extra/widgets/led/: lv_led.c
    ../../lvgl/src/extra/widgets/list/: lv_list.c
    ../../lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../lvgl/src/extra/widgets/span/: lv_span.c
    ../../lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../lvgl/src/extra/widgets/win/: lv_win.c
software components: CMSIS:CORE 6.1.0
