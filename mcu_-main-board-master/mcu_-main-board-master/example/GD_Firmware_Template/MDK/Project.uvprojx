# Keil uVision project Project.uvprojx, settings and files
target McuSTUDIO_F470VET6 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: ./keil5_disp_size_bar.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\Libraries\Include;..\USER\inc;..\Driver\CMSIS\GD\GD32F4xx\Include;..\Components\bsp;..\Components\oled;..\Components\gd25qxx;..\Components\ebtn;..\Components\sdio;..\Components\fatfs;..\APP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../USER/src/: gd32f4xx_it.c main.c systick.c
  group Components/bsp
    ../Components/bsp/: mcu_cmic_gd32f470vet6.c mcu_cmic_gd32f470vet6.h
  group Components/gd32qxx
    ../Components/gd25qxx/: gd25qxx.c lfs.c lfs_port.c lfs_util.c
  group Components/oled
    ../Components/oled/: oled.c
  group Components/ebtn
    ../Components/ebtn/: bit_array.h ebtn.c ebtn.h
  group Components/sdio
    ../Components/sdio/: sdio_sdcard.c
  group Components/fatfs
    ../Components/fatfs/: ff.c diskio.c
  group APP
    ../APP/: btn_app.c led_app.c oled_app.c scheduler.c usart_app.c sd_app.c rtc_app.c rtc_app.h
    ../../../../../Code_Demo/Mcu_Electronics_Studio/GD_Firmware/GD_Firmware_Template/APP/: adc_app.c
  group Peripherals
    ../Libraries/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../Libraries/: startup_gd32f450_470.s
  group CMSIS
    ../Driver/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Doc
    ../: readme.txt io_multiplexing_table.txt
software components: CMSIS:CORE 5.4.0, Utilities:perf_counter:Core 2.3.3
