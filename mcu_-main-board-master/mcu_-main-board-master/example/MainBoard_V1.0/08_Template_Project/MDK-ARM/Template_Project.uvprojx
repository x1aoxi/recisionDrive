# Keil uVision project Template_Project.uvprojx, settings and files
target Template_Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template_Project +hex
  AfterMake: ./Keil5_disp_size_bar_v0.3.exe
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,ICM20608,EMPL,EMPL_TARGET_STM32F1
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Components/aht20/inc;../Components/aht20/interface;../Components/delay/inc;../Components/icm20608/inc;../Components/icm20608/interface;../Components/w25qxx/inc;../Components/w25qxx/interface;../Components/Mcore_Button/inc;../Components/Mcore_LED/include;../Components/MultiTimer;../Components/bsp/include;../Components/bsp/priv_include;../Components/EasyLogger/inc;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FatFs/src/drivers;./Components/MPL/include;..\Components\MPL\eMPL-hal;..\Components\MPL\mllite;..\Components\MPL\mpl;..\Components\MPL\driver\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c sdio.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_mmc.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Components/bsp
    ../Components/bsp/src/: mcore_mainboard_v1_0.c mcore_bsp_board.c
    ../Components/bsp/include/: mcore_mainboard_v1_0.h bsp_board.h
    ../Components/bsp/priv_include/: bsp_err_check.h
  group Components/delay
    ../Components/delay/src/: delay.c
  group Components/EasyLogger
    ../Components/EasyLogger/port/: elog_port.c
    ../Components/EasyLogger/src/: elog.c elog_utils.c
  group Components/MultiTimer
    ../Components/MultiTimer/: MultiTimer.c
  group Components/aht20
    ../Components/aht20/src/: driver_aht20.c
    ../Components/aht20/interface/: stm32f103_driver_aht20_interface.c
  group Components/w25qxx
    ../Components/w25qxx/src/: driver_w25qxx.c
    ../Components/w25qxx/interface/: Mcore_MainBoard_driver_w25qxx_interface.c
  group Components/mcore_button
    ../Components/Mcore_Button/src/: button.c button_gpio.c
  group Components/mcore_rgbled
    ../Components/Mcore_LED/src/: led.c led_gpio.c led_pwm.c
  group Components/icm20608
    ../Components/icm20608/src/: driver_icm20608.c
    ../Components/icm20608/interface/: stm32f103_driver_icm20608_interface.c
  group Components/MPL
    ../Components/MPL/eMPL-hal/: eMPL_outputs.c
    ../Components/MPL/driver/stm32L/: log_stm32.c
    ../Components/MPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../Components/MPL/mpl/: libmpllib.lib
software components: CMSIS:CORE 5.6.0
